# Keil uVision project KEY.uvprojx, settings and files
target KEY (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KEY +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\SPI;..\HARDWARE\SD;..\HARDWARE\MALLOC;..\FATFS;..\FATFS\exfuns;..\user1\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c includes.h
  group HARDWARE
    ../HARDWARE/SPI/: SPI.c
    ../HARDWARE/SD/: MMC_SD.C
    ../HARDWARE/MALLOC/: malloc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_spi.c
  group README
    ../: README.TXT
  group FATFS
    ../FATFS/: diskio.c ff.c ffsystem.c ffunicode.c
    ../FATFS/exfuns/: exfuns.c
  group user1
    ../user1/src/: w25q64.c USART2.C key.c my1680.c AT24C04.c oled.c oledfont.c usart1.c
